# Keil uVision project Project.uvprojx, settings and files
target STM32L152C-Discovery (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152C-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xC,USE_STM32L152C_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L152C-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L152C-Discovery
    ../../../../../../Drivers/BSP/STM32L152C-Discovery/: stm32l152c_discovery.c
  group Example/User
    ../Src/: stm32l1xx_hal_msp.c main.c stm32l1xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Example/MDK-ARM
    ./: startup_stm32l152xc.s
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_dac.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_tim.c
software components: CMSIS:CORE 4.1.0
