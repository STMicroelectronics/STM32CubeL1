# Keil uVision project USBD_CDC.uvprojx, settings and files
target STM32L152D_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152ZD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000-0x805FFFF) IRAM(0x20000000-0x2000BFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM324xG-EVAL_USBD-FS
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L152xD,USE_HAL_DRIVER,USE_STM32L152D_EVAL
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L152D_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32l152xd.s
  group Application/User
    ../Src/: main.c stm32l1xx_hal_msp.c stm32l1xx_it.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L152D_EVAL
    ../../../../../../Drivers/BSP/STM32L152D_EVAL/: stm32l152d_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 4.3.0
