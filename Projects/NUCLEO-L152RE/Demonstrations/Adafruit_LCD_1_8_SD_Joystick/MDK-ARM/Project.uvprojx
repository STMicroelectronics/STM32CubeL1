# Keil uVision project Project.uvprojx, settings and files
target STM32L152RE_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20013FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L152xE,USE_STM32L1XX_NUCLEO,USE_HAL_DRIVER
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../Drivers/BSP/Adafruit_Shield;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Doc
    ../: readme.txt
  group Demo/User
    ../Src/: main.c stm32l1xx_it.c fatfs_storage.c
  group Demo/MDK-ARM
    ./: startup_stm32l152xe.s
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c stm32_adafruit_sd.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_rcc.c stm32l1xx_hal_dma.c stm32l1xx_hal_spi.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Src/: sd_diskio.c
software components: CMSIS:CORE 4.3.0
