# Keil uVision project USBD_DFU.uvprojx, settings and files
target STM32L1_Nucleo (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20013FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152RE_NUCLEO_USBD-FS
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L152xE,USE_HAL_DRIVER,USE_STM32L1xx_NUCLEO
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Application/User
    ../Src/: main.c stm32l1xx_it.c usbd_conf.c usbd_desc.c usbd_dfu_flash.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_sd.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/DFU
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 4.3.0
