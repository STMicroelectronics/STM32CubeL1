# IAR project USBD_DFU.ewp, settings and files
configuration STM32L1_Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; USE_HAL_DRIVER; USE_STM32L1xx_NUCLEO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\DFU\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_DFU.bin
  ILINK.IlinkOutputFile: STM32L152RE_NUCLEO_USBD-FS.out
  ILINK.IlinkIcfFile: stm32l152xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l152xe.s
  group Application/User
    ../Src/: main.c stm32l1xx_it.c usbd_conf.c usbd_desc.c usbd_dfu_flash.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_sd.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/DFU
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
