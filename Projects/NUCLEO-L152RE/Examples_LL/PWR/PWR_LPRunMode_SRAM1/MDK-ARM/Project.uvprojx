# Keil uVision project Project.uvprojx, settings and files
target STM32L152RE_NUCLEO (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152RE_NUCLEO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L152xE,USE_STM32L1XX_NUCLEO,USE_FULL_LL_DRIVER,VECT_TAB_SRAM
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x1400
  memory RVCT9: RAM 0x20001400 size 0x14000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_gpio.c
  group Example/User
    ../Src/: main.c stm32l1xx_it.c
  group Drivers/STM32L1xx_LL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32l152xe.s
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
