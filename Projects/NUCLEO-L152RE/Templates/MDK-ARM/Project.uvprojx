# Keil uVision project Project.uvprojx, settings and files
target STM32L152RE_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20013FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L152xE,USE_STM32L1XX_NUCLEO,USE_HAL_DRIVER
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../Drivers/BSP/Components/Common;../../../../Utilities/Log;../../../../Utilities/CPU;../../../../Drivers/BSP/Adafruit_Shield
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l1xx_hal_msp.c stm32l1xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32l152xe.s
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_dma.c stm32l1xx_hal_cortex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_uart.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
